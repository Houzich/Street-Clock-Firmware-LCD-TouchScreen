# Keil uVision project Street_Clock_F429.uvprojx, settings and files
target Street_Clock_F429 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Street_Clock_Night_Light +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_RTX, STM32F4, HSE_VALUE=8000000, DATA_IN_ExtSDRAM, STM32F429I_DISCOVERY, USE_FULL_ASSERT
  c include: .\Source;..\Firmware\CLOCK;..\Firmware\LCD;..\Firmware\RTC;..\LCD_Simulate\STemWinLibrary522\Software;..\Firmware\FLASH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0xd0100000 size 0x700000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./Source/: main.c main.h stm32f4xx_it.c stm32f4xx_it.h
  group LCD
    ../Firmware/LCD/: WindowDLG.h
    ../LCD_Simulate/STemWinLibrary522/: SoftwareWindowDLG.c
  group RTC
    ../Firmware/RTC/: RTC.c RTC.h
  group CLOCK
    ../Firmware/CLOCK/: Board_LCD.c Board_LCD.h Buttons.c Buttons.h Clock.c Clock_F4.h Settings.c Settings.h Street_Clock.c Street_Clock.h GPS.c GPS.h Date.c Date.h
  group FLASH
    ../Firmware/FLASH/: FLASH.c FLASH.h
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, Compiler:I/O:STDOUT 1.2.0, Board Support:LED 1.0.0, Board Support:Touchscreen 1.0.0, Board Support:emWin LCD 1.0.0, CMSIS Driver:I2C 2.10, CMSIS Driver:SPI 2.15, CMSIS Driver:USART 2.13, Device:STM32Cube Framework:Classic 1.7.9, Device:STM32Cube HAL:Common 1.7.9, Device:STM32Cube HAL:Cortex 1.7.9, Device:STM32Cube HAL:DMA 1.7.9, Device:STM32Cube HAL:DMA2D 1.7.9, Device:STM32Cube HAL:Flash 1.7.9, Device:STM32Cube HAL:GPIO 1.7.9, Device:STM32Cube HAL:I2C 1.7.9, Device:STM32Cube HAL:LTDC 1.7.9, Device:STM32Cube HAL:PWR 1.7.9, Device:STM32Cube HAL:RCC 1.7.9, Device:STM32Cube HAL:RTC 1.7.9, Device:STM32Cube HAL:SPI 1.7.9, Device:STM32Cube HAL:UART 1.7.9, Device:STM32Cube HAL:USART 1.7.9, Device:Startup 2.6.3, Graphics Display:STM32F429I-Discovery 1.0.2, Graphics:CORE 6.10.8, Graphics:Input Device:Touchscreen 6.10.8
