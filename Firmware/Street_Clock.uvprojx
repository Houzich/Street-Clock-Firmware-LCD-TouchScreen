# Keil uVision project Street_Clock.uvprojx, settings and files
target Street_Clock (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Street_Clock
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: LCD_800_480,USE_RTX,STM32F7
  c include: ..\LCD_Simulate\STemWinLibrary522\Software;.\LCD;.\CLOCK;.\RTC;.\Source;.\FLASH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group Source
    ./Source/: example.c main.c main.h stm32f7xx_it.c stm32f7xx_it.h
  group LCD
    ./LCD/: WindowDLG.h
    ../LCD_Simulate/STemWinLibrary522/: SoftwareWindowDLG.c
  group RTC
    ./RTC/: RTC.c RTC.h
  group CLOCK
    ./CLOCK/: Buttons.c Buttons.h Clock.c Clock_F7.h Settings.c Settings.h Street_Clock.c Street_Clock.h Board_LCD.c Board_LCD.h GPS.c GPS.h Date.c Date.h
  group FLASH
    ./FLASH/: FLASH.c FLASH.h
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:I/O:STDOUT 1.2.0, Board Support:Drivers:Basic I/O 1.1.0, Board Support:Drivers:SDRAM 1.1.0, Board Support:Drivers:Touch Screen 1.1.0, Board Support:LED 1.1.0, Board Support:Touchscreen 1.1.0, Board Support:emWin LCD 1.1.0, CMSIS Driver:USART 1.16.0, Device:STM32Cube Framework:Classic 1.2.8, Device:STM32Cube HAL:Common 1.2.8, Device:STM32Cube HAL:Cortex 1.2.8, Device:STM32Cube HAL:DMA 1.2.8, Device:STM32Cube HAL:DMA2D 1.2.8, Device:STM32Cube HAL:DSI 1.2.8, Device:STM32Cube HAL:Flash 1.2.8, Device:STM32Cube HAL:GPIO 1.2.8, Device:STM32Cube HAL:I2C 1.2.8, Device:STM32Cube HAL:LTDC 1.2.8, Device:STM32Cube HAL:PWR 1.2.8, Device:STM32Cube HAL:RCC 1.2.8, Device:STM32Cube HAL:RTC 1.2.8, Device:STM32Cube HAL:SDRAM 1.2.8, Device:STM32Cube LL:Common 1.2.8, Device:STM32Cube LL:PWR 1.2.8, Device:STM32Cube LL:RCC 1.2.8, Device:STM32Cube LL:UTILS 1.2.8, Device:Startup 1.2.5, Graphics Display:STM32F769I-Discovery 1.0.2, Graphics:CORE 6.16.3, Graphics:Input Device:Touchscreen 6.16.3
